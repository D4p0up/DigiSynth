# Repository D4p0up/DigiSynth

## KiCad design DigiSynth.kicad_pcb

Parts:
C1, C2: 2.2u; C_0805
C3, C4: 100u; C_0805
C5: 10u; C_0805
C6, C7, C8, C9, C10, C11, C12, C13, C14, C15, C16, C17, C18, C19, C20, C21: 1n; C_0805
C22, C23, C24, C25, C26, C27, C28: 100n; C_0805
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: LED; LED_D3.0mm
J1: Line Out; PJ311_3.5mm_Jack
J2: Headphone Out; PJ311_3.5mm_Jack
J3: DIN-5; MIDI_DIN5
J4, J5: Conn_01x03; Pin_Header_Straight_1x03_Pitch2.54mm
Q1, Q2: PZT2222A; SOT-223
R1, R2: 3.3k; R_0805
R3, R4, R18, R19, R20, R21, R22, R23, R24, R26, R27: 1k; R_0805
R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R25, R28: 100; R_0805
RV1, RV2, RV3, RV4, RV5, RV6, RV7, RV8, RV9, RV10: 10k; Potentiometer_Alps_RK09L_Sleve_Single_Horizontal
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push_Dual; SW_PUSH_6mm
U1: Teensy3.2; Teensy30_31_32_LC
U2: 74HC595; DIP-16_W7.62mm
U3: 6N135; DIP-8_W7.62mm

Connections:
A0: C6.2, RV1.2, U1.21 (14_A0_SCK)
A1: C11.2, RV6.2, U1.22 (15_A1_CS_Touch)
A2: C7.2, RV2.2, U1.23 (16_A2_SCL0_Touch)
A3: C12.2, RV7.2, U1.24 (17_A3_SDA0_Touch)
A4: C8.2, RV3.2, U1.25 (18_A4_SDA0_Touch)
A5: C13.2, RV8.2, U1.26 (19_A5_SCL0_Touch)
A6: C9.2, RV4.2, U1.27 (20_A6_CS_PWM)
A7: C14.2, RV9.2, U1.28 (21_A7_RX1_CS_PWM)
A8: C10.2, RV5.2, U1.29 (22_A8_Touch_PWM)
A9: C15.2, RV10.2, U1.30 (23_A9_Touch_PWM)
B0: C16.2, R19.1, SW1.1, U1.9 (7_RX3_DOUT)
B1: C18.2, R21.1, SW3.1, U1.10 (8_TX3_DIN)
B2: C17.2, R20.1, SW2.1, U1.11 (9_RX2_CS_PWM)
B3: C19.2, R22.1, SW4.1, U1.14 (12_DIN)
B4: C20.2, R23.1, SW5.1, U1.4 (2)
GND: C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C13.1, C14.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), J1.3, J2.3, J4.2, J5.2, R1.1, R2.1, R9.1, R25.1, R27.2, RV1.3, RV2.3, RV3.3, RV4.3, RV5.3, RV6.3, RV7.3, RV8.3, RV9.3, RV10.3, SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, SW6.2, U1.1 (GND), U1.17 (GND), U1.32 (AGND), U2.8 (GND), U3.5
L0: R16.2, U1.6 (4_RX_PWM)
L1: R15.2, U1.7 (5_TX1_PWM)
L2: R14.2, U1.8 (6_PWM)
MIDI_IN: R18.1, U1.2 (0_RX1_Touch), U3.6
MOSI: U1.13 (11_DOUT), U2.14 (SER)
unnamed: C1.1, R1.2, R3.2
unnamed: C1.2, J1.2, J4.3
unnamed: C2.1, R2.2, R4.2
unnamed: C2.2, J1.1, J4.1
unnamed: C3.1, Q2.2, R25.2
unnamed: C3.2, J2.1, J5.1
unnamed: C4.1, Q1.2, R9.2
unnamed: C4.2, J2.2, J5.3
unnamed: C5.1, R28.1
unnamed: C5.2, C28.2, Q1.1, Q2.1, R26.2, R27.1
unnamed: D1.2 (A), R5.1
unnamed: D2.2 (A), R6.1
unnamed: D3.2 (A), R7.1
unnamed: D4.2 (A), R8.1
unnamed: D5.2 (A), R10.1
unnamed: D6.2 (A), R11.1
unnamed: D7.2 (A), R12.1
unnamed: D8.2 (A), R13.1
unnamed: D9.2 (A), R14.1
unnamed: D10.2 (A), R15.1
unnamed: D11.2 (A), R16.1
unnamed: J3.4, R17.2
unnamed: J3.5, U3.3
unnamed: R5.2, U2.15 (QA)
unnamed: R6.2, U2.2 (QC)
unnamed: R7.2, U2.4 (QE)
unnamed: R8.2, U2.6 (QG)
unnamed: R10.2, U2.1 (QB)
unnamed: R11.2, U2.3 (QD)
unnamed: R12.2, U2.5 (QF)
unnamed: R13.2, U2.7 (QH)
unnamed: R17.1, U3.2
SCK: U1.20 (13_LED_SCK), U2.11 (SRCLK)
SS: U1.12 (10_TX2_CS_PWM), U2.12 (RCLK)
TYPE: C21.2, R24.1, SW6.1, U1.5 (3_TX_PWM)
VCC: C22.2, Q1.3, Q2.3, R26.1, U1.33 (Vin)
VOUT: R3.1, R4.1, R28.2, U1.19 (A14/DAC)
VSS: C23.2, C24.2, C25.2, C26.2, C27.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, RV1.1, RV2.1, RV3.1, RV4.1, RV5.1, RV6.1, RV7.1, RV8.1, RV9.1, RV10.1, U1.31 (3.3V_max100mA), U2.10 (SRCLR), U2.16 (VCC), U3.8

Board: 2 copper layers, 95.2 x 95.2 mm, 93 parts (6 on the bottom side), 59 nets.

## Commit log

2018-02-07 Version Beta 1 - Commande Seeedstudio du 07/02/2018
2018-03-08 Maj #2
